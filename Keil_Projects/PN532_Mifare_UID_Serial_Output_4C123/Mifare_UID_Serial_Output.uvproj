# Keil uVision project Mifare_UID_Serial_Output.uvproj, settings and files
target Mifare_UID_Serial_Output (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Mifare_UID_Serial_Output
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Files
    ./: startup.s LED.c PLL.c UART.c PN532_SSI.c PN532.c Mifare_UID_Serial_Output.c
