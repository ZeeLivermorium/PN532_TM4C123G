# Keil uVision project ISO14443A_Detect_ST7735.uvproj, settings and files
target ISO14443A_Detect_ST7735 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: ISO14443A_Detect_ST7735
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Files
    ../inc/: LED.c PLL.c PN532.c PN532_SSI.c ST7735.c startup.s
    ./: ISO14443A_Detect_ST7735.c
