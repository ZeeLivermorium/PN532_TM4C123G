# Keil uVision project NDEF_Card_Emulate.uvproj, settings and files
target NDEF_Card_Emulate (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: NDEF_Card_Emulate
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --C99
  c include: ../../lib/_tm4c , ../../lib/common/inc,  ../../lib/PN532/inc,  ../../lib/NDEF/inc,  ../../lib/PICC/inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ../../lib/common/src/: SSI.c Serial.c PLL.c startup.s LED.c
    ../../lib/PN532/src/: PN532.c PN532_SSI.c
    ./: main.c
    ../../lib/NDEF/src/: NDEF_Message.c NDEF_Record.c
    ../../lib/PICC/src/: PN532_cardEmulation.c
