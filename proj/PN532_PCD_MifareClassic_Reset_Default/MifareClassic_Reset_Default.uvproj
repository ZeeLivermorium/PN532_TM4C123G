# Keil uVision project MifareClassic_Reset_Default.uvproj, settings and files
target MifareClassic_Reset_Default (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: MifareClassic_Reset_Default
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --C99
  c include: ../../lib/common/inc,  ../../lib/PN532/inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c
    ../../lib/PN532/src/: PN532.c PN532_SSI.c
    ../../lib/common/src/: PLL.c Serial.c SSI.c startup.s
